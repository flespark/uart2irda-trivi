# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: User;Include/STM32F10x_StdPeriph_Driver/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c functions.c functions.h stm32f10x_it.c stm32f10x_conf.h
  group CMSIS
    ./Include/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ./Include/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h
  group Libraries
    ./Include/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_rcc.c
  group Startup
    ./Include/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
software components: CMSIS:CORE 5.2.0
